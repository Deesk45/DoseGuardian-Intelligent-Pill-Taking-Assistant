# Keil uVision project DOSE_GARDIAN_FINAL.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2129 NXP
  cpu: IRAM(0x40000000-0x40003FFF) IROM(0-0x3FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: DOSE_GARDIAN_FINAL
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x40000000 size 0x4000
  group Source Group 1
    ./: Startup.s def_delay.c DOSE_GAURDIAN.c KEYPAD.c LCD.c MD_CLK_SET.c MD_CLK_SET_2.c RTC.c
